# Keil uVision project eLight.uvproj, settings and files
target eLight (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: eLight +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ../src/: STARTUP.A51 hal.c key.c light.c main.c
